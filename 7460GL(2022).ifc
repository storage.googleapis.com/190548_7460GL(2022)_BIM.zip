Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-03-21T14:01:29
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 21 14:01:29 2022 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{65F98A8F-134A-4893-8F82-F3E60A2D173C}\ifc * Database version: 5507 * Database creation date: Mon Mar 21 14:01:27 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 21 14:01:28 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 21 14:01:28 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 7460GL Shower faucet, 7460GL(2022):7460GL Shower faucet:472755
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - ShowerDefaultElevation: 900 mm
Type - Dimensions - NominalDepth: 81.1278 mm; NominalHeight: 63.4 mm; NominalWidth: 290 mm
Type - General - Author: BIMStone; BIMObjectName: 7460GL(2022); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 18/03/2022
Type - Green Building Properties - EAN Number: 6414150100161; EN Standard: EN 1111; ETIM Class Number: EC011329 Shower mixing tap; Noise Class: I (ISO 3822) Oras lab.; Sales Package dimensions (LxWxH): 294 x 164 x 83; Sales Package gross weight: 1.805 kg; Sales Package package weight: 0.22754 kg; UNSPSC Class Number: 30181503 Showers; URL Declaration of Conformity: http://static.oras.com/DoC/7460GL; URL REACH: http://static.oras.com/doc/reach
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/7460GL; Catalog Drawing URL: http://static.oras.com/catdrw/7460GL; Dimension Drawing URL: http://static.oras.com/dimdrw/7460GL; FDV Document URL: http://www.oras.com/datasheet/7460GL/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/7460GL; Group: Shower faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/7460GL; Interactive AR View URL: https://static.oras.com/AR/7460GL; Item Type: Sales item; Manufacturer: Oras; Market: International;Sweden; Mobile Product Information URL: http://mpi.oras.com/7460GL; Model: 7460GL Shower faucet; Name_en: 7460GL Shower faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 7460GL; Product Family: Oras Nova; Product Image URL: http://static.oras.com/image/7460GL; Product URL: http://static.oras.com/7460GL; Technical DataSheet URL: http://www.oras.com/datasheet/7460GL/en; Type Name: 7460GL Shower faucet; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Additional Features: lead free, < 0,1% Pb; Backflow Prevention EN1717: EB; Connection: Direct connection;Internal thread; Connection Size: G3/4; Eco Flow At 300kPa: 0.00353147 m3/s; Flow Rate At 300kPa: 0.000706293 m3/s; Installation Type: Wall mounted; Installation Width: cc150 mm; Lever Handle: Temperature control handle;Flow control handle; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: Ceramic head part for flow control;Thermostatic cartridge for automatic temperature control;Non-return valve(s);Litter filter(s); Shower Parts: Eco flow control; Surface treatment: Chrome; Temperature Adjustments: Safety stop against scalding at 38°C;Temperature preset fixable; Working Pressure: 100 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 7460GL(2022); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 7460GL; Name: 7460GL Shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 290x80x65 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 7460GL; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 7460GL Shower faucet
Constraints - Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0506882 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 20 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.00152165 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 7460GL(2022): 7460GL Shower faucet; Family and Type: 7460GL(2022): 7460GL Shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 7460GL(2022): 7460GL Shower faucet; Type Id: 7460GL(2022): 7460GL Shower faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
